# Keil uVision project IIC.uvprojx, settings and files
target IIC (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IIC +hex
  AfterMake: E:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\Device\LED;..\Device\KEY;..\Device\LCD;..\Device\RTC;..\Device\RTC;..\Device\WKUP;..\Device\ADC;..\Device\DAC;..\Device\DMA;..\Device\IIC;..\Device\24CXX;..\USMART;..\Device\cht8305
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_i2c.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group Device
    ../Device/LED/: led.c
    ../Device/LCD/: lcd.c
    ../Device/KEY/: key.c
    ../Device/IIC/: myiic.c
    ../Device/cht8305/: Cht8305.c
    ../Device/24CXX/: 24cxx.c
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group README
    ../: README.TXT
